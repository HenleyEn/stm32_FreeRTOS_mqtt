# Keil uVision project stm32_FreeRTOS_template.uvprojx, settings and files
target stm32_FreeRTOS_template (5040049::V5.04 update 1 (build 49)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_FreeRTOS_template
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\STM32F10xLIB\inc;..\MDK_ARM;..\USER;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\DRIVE\inc;..\DRIVE\mqttclient\common;..\DRIVE\mqttclient\mqtt;..\DRIVE\mqttclient\mqttclient;..\DRIVE\mqttclient\network;..\DRIVE\mqttclient\platform\FreeRTOS;..\DRIVE\mqttclient\test;..\DRIVE\HAL;..\DRIVE\RTT\SEGGER_RTT_V782a\RTT;..\DRIVE\RTT\SEGGER_RTT_V782a\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c stm32f10x_it.c include.h FreeRTOSConfig.h projectConfig.h
  group STM32F10XLIB
    ../STM32F10xLIB/src/: misc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FREERTOS/SOURCE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FREERTOS/PORT
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
  group MDK_ARM
    ../MDK_ARM/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group DRIVE
    ../DRIVE/src/: ringbuf.c ESP8266_AT.c task_manager.c fifo.c dev_usart.c bsp_usart_config.c
    ../DRIVE/HAL/: hal_at.c
  group mqtt/common
    ../DRIVE/mqttclient/common/: mqtt_list.c random.c
  group mqtt/mqtt
    ../DRIVE/mqttclient/mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group mqtt/client
    ../DRIVE/mqttclient/mqttclient/: mqttclient.c
  group mqtt/network
    ../DRIVE/mqttclient/network/: nettype_tcp.c network.c
  group mqtt/platform
    ../DRIVE/mqttclient/platform/FreeRTOS/: platform_memory.c platform_mutex.c platform_net_socket.c platform_thread.c platform_timer.c
  group RTT
    ../DRIVE/RTT/SEGGER_RTT_V782a/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 5.6.0
